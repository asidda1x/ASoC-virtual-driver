## Kconfig
```kconfig
config SND_SOC_MY
	tristate "Virtual driver for SoC audio support"
	---help---

	  If you want my ASoC support, you should say Y here and also to the
```
